MACRO cap_cmim_2GCWCG
  CLASS BLOCK ;
  FOREIGN cap_cmim_2GCWCG ;
  ORIGIN 7.840 3.100 ;
  SIZE 13.200 BY 6.200 ;
  OBS
      LAYER Metal5 ;
        RECT -7.840 -3.100 7.140 3.100 ;
      LAYER TopMetal1 ;
        RECT -7.040 -2.820 5.360 2.820 ;
        RECT 6.200 -2.820 7.840 2.820 ;
  END
END cap_cmim_2GCWCG
END LIBRARY

